# IAR project ucos_vfs.ewp, settings and files
configuration stm32f4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: bsp\stm32f4\Libraries\STM32F4xx_StdPeriph_Driver\inc; bsp\stm32f4\Libraries\CMSIS\Device\ST\STM32F4xx\Include; bsp\stm32f4\Libraries\CMSIS\Include; bsp\stm32f4\board; bsp\stm32f4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: bsp\stm32f4\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration stm32f1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: bsp\stm32f1\Libraries\CMSIS\CM3\CoreSupport; bsp\stm32f1\Libraries\STM32F10x_StdPeriph_Driver\inc; bsp\stm32f1\board; bsp\stm32f1
  OBJCOPY.OOCOutputFile: ucos_vfs.srec
  group (top)
    ./: configs.h main.c
  group bsp/stm32f1
    bsp/stm32f1/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
  group bsp/stm32f1/board
    bsp/stm32f1/board/: clock.c clock.h usart.c usart.h
  group bsp/stm32f1/lib/cmsis
    bsp/stm32f1/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    bsp/stm32f1/: startup_stm32f10x_md.s
  group bsp/stm32f1/lib/src
    bsp/stm32f1/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group bsp/stm32f4
    bsp/stm32f4/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group bsp/stm32f4/board
    bsp/stm32f4/board/: clock.c clock.h usart.c usart.h
  group bsp/stm32f4/lib/cmsis
    bsp/stm32f4/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group bsp/stm32f4/lib/src
    bsp/stm32f4/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
